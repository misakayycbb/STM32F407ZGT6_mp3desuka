# Keil uVision project Project.uvprojx, settings and files
target HZK16 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HZK16 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\STM32F10x_StdPeriph_Driver_v3.5\inc;..\Libraries\STM32F10x_StdPeriph_Driver_v3.5\src;..\User\Main;..\User\Lcd;..\User\SD;..\User\w25q16;..\User\Delay;..\Fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User/Main
    ../User/Main/: main.c stm32f10x_it.c hw_config.c
  group Libraries/StdPeriph_Driver_v3.5
    ../Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c misc.c
  group Libraries/CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group User/Lcd
    ../User/Lcd/: 107_32_Driver_IO16.c
  group User/Delay
    ../User/Delay/: delay.c
  group User/SD
    ../User/SD/: sddriver.c
  group Fatfs
    ../Fatfs/: diskio.c ff.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.6.0
